# Keil uVision project crupto_new_c.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C129ENCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: crupto_new_c +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c config.h fp_generic.c P503_internal.h P503.c P503_api.h fpx.c fpx.h ec_isogeny.c sidh.c sike.c random.c random.h fips202.h fips202.c test_mul.s mul.s
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
